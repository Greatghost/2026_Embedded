# Keil uVision project balanced_infantry.uvprojx, settings and files
target HUST_infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: balanced_infantry
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Algorithm\inc;..\FreeRTOS\include;..\Library\inc;..\Mylib\inc;..\Task\inc;..\User\inc;..\Library\CMSIS;..\User\inc\os;..\User\inc\sys;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Library\SEGGER_RTT_V784\RTT;..\Library\SEGGER_RTT_V784\Config;..\Library\CMSIS\FastMath;..\User\inc\FATFS;..\User\inc\app;..\User\inc\motor;..\User\inc\peripheral;..\User\inc\tools;..\User\inc\config;..\Mylib\inc\tof
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/app
    ../User/src/sys/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../User/src/app/: ChasisController.c GimbalReceive.c ins.c main.c HeatControl.c PowerLimit.c mecanum.c steer.c GimbalSend.c omni.c ChassisSolver.c NingCap.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dbgmcu.c stm32f4xx_spi.c arm_cortexM4lf_math.lib
    ../Library/SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Library/CMSIS/FastMath/: arm_atan2_f32.c
    ../Library/CMSIS/MathLib/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group Mylib
    ../Mylib/src/: os_tick.c can2.c can1.c counter.c pc_uart.c bluetooth.c can_send.c wifi.c i2c.c iwdg.c led.c bsp_superpower.c bsp_referee.c dji_remote.c can_receive.c
  group Algorithm
    ../Algorithm/src/: QuaternionEKF.c kalman_filter.c algorithmOfCRC.c crc32.c user_lib.c pid.c wheel_ins.c Observer.c RLS_Identification.c my_filter.c SystemIdentification.c SignalGenerator.c TD.c accel.c
  group Task
    ../Task/src/: Start_Task.c ChasisEstimateTask.c CPU_Task.c Test_Task.c ChasisControlTask.c Offline_Task.c SDCardTask.c BlueToothTask.c iwdgTask.c ActionTask.c PowerControlTask.c GimbalTask.c RefereeTask.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group SD
    ../Mylib/src/: bsp_spi_sdcard.c
    ../User/inc/FATFS/: ff.c diskio.c
  group User/motor
    ../User/src/motor/: M2006.c GM6020.c M3508.c
  group User/peripheral
    ../User/src/peripheral/: icm20602.c ina260.c remote_control.c SuperPower.c Referee.c
  group Uset/tools
    ../User/src/tools/: debug.c tools.c ZeroCheck.c
  group config
    ../User/inc/config/: robot_config.c robot_config.h can_config.h
