# Keil uVision project sentry_chassis_test.uvprojx, settings and files
target sentry_chassis_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: sentry_chassis_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../application/inc;../bsp/boards/inc;../bsp/usb/inc;../components/algorithm/inc;../components/devices/inc;../components/tools/inc;../Drivers/USB;../Task/inc;../Drivers/FastMath;../components/motor/inc;../config
  asm include: ../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User
    ./: startup_stm32f407xx.s
    ../Drivers/FastMath/: arm_atan2_f32.c
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group algorithm
    ../components/algorithm/src/: algorithmOfCRC.c crc32.c kalman_filter.c my_filter.c Observer.c pid.c QuaternionEKF.c RLS_Identification.c SignalGenerator.c SystemIdentification.c TD.c user_lib.c
  group application
    ../application/src/: BombBay.c ChassisGet.c ChassisSend.c ChassisSolver.c FrictionWheel.c Gimbal.c pc_serial.c remote_control.c ToggleBullet.c wbus_decoder.c
  group BSP
    ../bsp/boards/src/: bsp_can.c bsp_dwt.c bsp_led.c bsp_PWM.c bsp_rc.c bsp_spi.c
  group device
    ../Drivers/USB/: usbd_cdc.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group motor
    ../components/motor/src/: DM_Motor.c GM6020.c M2006.c M3508.c Motor_Typdef.c
  group BSP/USB
    ../bsp/usb/src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ../bsp/boards/src/: bsp_buzzer.c bsp_led.c
  group IMU
    ../components/devices/src/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group Task
    ../Task/src/: ActionTask.c BlueToothTask.c ChassisTask.c CPU_Task.c GimbalTask.c ins_task.c iwdgTask.c led_flow_task.c Offline_Task.c Test_Task.c ShootTask.c
  group tools
    ../components/tools/src/: debug.c tools.c ZeroCheck.c
  group Config
    ../config/: can_config.h can_send_config.c can_send_config.h gimbal_config.h robot_config.h toggle_config.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 4.3.0
